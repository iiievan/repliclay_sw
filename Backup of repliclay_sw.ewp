# IAR project Backup of repliclay_sw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AM3359 TexasInstruments AM3359
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 53
  General.FPU2: 3
  ICCARM.CCDefines: am335x; beaglebone_black
  ICCARM.CCIncludePath2: src; src\app; lib\include; lib; lib\include\hw; lib\include\armv7a; lib\include\armv7a\am335x; lib\include\usblib; lib\drivers; lib\platform; lib\system_config; lib\system_config\am335x; lib\utils; lib\uC-LIB; lib\uC-LIB\Ports\ARM; vendor\uCOS-II\Ports\ARM-Cortex-A; vendor\uCOS-II\Source; vendor\uC-CPU; vendor\uC-CPU\ARM-Cortex-A; src\cppdrivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: lib; lib\include; src; lib\include; lib\include\armv7a; lib\include\armv7a\am335x; lib\include\hw; lib\include\usblib
  OBJCOPY.OOCOutputFile: repliclay_sw.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: repliclay_sw.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: repliclay_sw.icf
  group lib/drivers
    lib/drivers/: cppi41dma.c cpsw.c dcan.c dmtimer.c ecap.c edma.c ehrpwm.c elm.c gpio_v2.c gpmc.c hs_mmcsd.c hsi2c.c mailbox.c mcasp.c mcspi.c mdio.c phy.c raster.c rtc.c tsc_adc.c uart_irda_cir.c usb.c usbphyGS70.c watchdog.c
  group lib/include
    lib/include/: ascii.h board.h cmdline.h consoleUtils.h cppi41dma.h cpsw.h dcan.h debug.h delay.h dmtimer.h ecap.h edma.h ehrpwm.h elm.h epwm.h error.h gpio.h gpio_v2.h gpmc.h hs_mmcsd.h hsi2c.h mailbox.h mcasp.h mcspi.h mdio.h misc.h perf.h phy.h pruss.h raster.h rtc.h systick.h tsc_adc.h uart_irda_cir.h uartStdio.h usb.h vpif.h watchdog.h
  group lib/include/armv7a
    lib/include/armv7a/: cache.h cp15.h cpu.h mmu.h
  group lib/include/armv7a/am335x
    lib/include/armv7a/am335x/: am335.h beaglebone.h clock.h device.h edma_event.h evmAM335x.h evmskAM335x.h interrupt.h pin_mux.h
  group lib/include/hw
    lib/include/hw/: hw_cm_cefuse.h hw_cm_device.h hw_cm_dpll.h hw_cm_gfx.h hw_cm_mpu.h hw_cm_per.h hw_cm_rtc.h hw_cm_wkup.h hw_control_AM335x.h hw_cpsw_ale.h hw_cpsw_cpdma.h hw_cpsw_cpts.h hw_cpsw_port.h hw_cpsw_sl.h hw_cpsw_ss.h hw_cpsw_wr.h hw_dcan.h hw_ddr2_mddr.h hw_dmtimer.h hw_dmtimer_1ms.h hw_ecap.h hw_edma3cc.h hw_edma3tc.h hw_ehrpwm.h hw_elm.h hw_emif4d.h hw_emifa2.h hw_gpio_v2.h hw_gpmc.h hw_hs_mmcsd.h hw_hsi2c.h hw_intc.h hw_lcdc.h hw_mailbox.h hw_mcasp.h hw_mcspi.h hw_mdio.h hw_prm_cefuse.h hw_prm_gfx.h hw_prm_mpu.h hw_prm_per.h hw_prm_wkup.h hw_pwmss.h hw_rtc.h hw_tps65217.h hw_tps65910.h hw_tsc_adc_ss.h hw_types.h hw_uart_irda_cir.h hw_usb.h hw_usbOtg_AM335x.h hw_usbphyGS70.h hw_watchdog.h soc_AM335x.h
  group lib/platform
    lib/: beaglebone.c
  group lib/system_config
    lib/system_config/: cache.c cp15.S cpu.S init.S mmu.c
  group lib/system_config/am335x
    lib/system_config/am335x/: clock.c device.c exceptionhandler.S interrupt.c startup.c
  group lib/uC-LIB
    lib/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group lib/uC-LIB/Ports/ARM
    lib/uC-LIB/Ports/ARM/: lib_mem_a.asm
  group lib/utils
    lib/utils/: ascii.c board.c cmdline.c consoleUtils.c delay.c misc.c perf.c systick.c uartStdio.c
  group src
    src/: hal_mmu.c init.cpp main.cpp
  group src/app
    src/app/: app_cfg.h app_hooks.c app_utils.cpp app_utils.h cpu_cfg.h lib_cfg.h os_cfg.h
  group src/cppdrivers
    src/cppdrivers/: CONTROL_MODULE.CPP CONTROL_MODULE.h DM_Timer.cpp DM_Timer.h HS_I2C.cpp HS_I2C.h I2C_EEPROM.CPP I2C_EEPROM.h INTC.cpp INTC.h OS_Timer.h PRCM.cpp PRCM.h
  group startup
    startup/: amm335x_init.S
  group uC-CPU
    vendor/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM-Cortex-A
    vendor/uC-CPU/ARM-Cortex-A/: cpu_a.asm uC_cpu.h
  group uCOS-II/Ports/ARM-Cortex-A
    vendor/uCOS-II/Ports/ARM-Cortex-A/: os_cpu.h os_cpu_a_vfp-d16.asm os_cpu_a_vfp-d32.asm os_cpu_a_vfp-none.asm os_cpu_c.c
  group uCOS-II/Source
    vendor/uCOS-II/Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
