<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\am335x.ewp</path>
    </project>
    <batchBuild />
</workspace>
