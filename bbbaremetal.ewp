# IAR project bbbaremetal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AM3359 TexasInstruments AM3359
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 53
  General.FPU2: 3
  ICCARM.CCDefines: am335x; beaglebone_black; beaglebone
  ICCARM.CCIncludePath2: lib\; lib\include\; lib\include\hw; lib\include\armv7a; lib\include\armv7a\am335x; lib\grlib; lib\usblib\include; app; regs; utils; utils\fsm_c; utils\fsm_c\fsm_list; periph; \periph\pins
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: lib\; lib\include\; lib\include\hw; lib\include\armv7a; lib\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: bbbaremetal.bin
  postbuild: "ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: AM335x.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: AM335x.icf
  group app
    app/: am335x_clock_data.c board.hpp init.cpp init.h main.cpp
  group lib/drivers
    lib/drivers/: cppi41dma.c cpsw.c dcan.c dmtimer.c ecap.c edma.c ehrpwm.c elm.c gpio_v2.c gpmc.c hal_mmu.c hs_mmcsd.c hsi2c.c mailbox.c mcasp.c mcspi.c mdio.c phy.c raster.c rtc.c tsc_adc.c uart_irda_cir.c usb.c usbphyGS70.c watchdog.c
  group lib/platform
    lib/platform/: board.c cpsw.c ctlregcontext.c dmtimer.c edma.c eeprom.c gpio.c hs_mmcsd.c hsi2c.c rtc.c sysdelay.c sysperf.c timertick.c uart.c uartConsole.c usb.c watchdog.c
  group lib/system
    lib/system/: cache.c clock.c cp15.S cpu.S device.c exceptionhandler.S init.S interrupt.c mmu.c
  group lib/utils
    lib/utils/: ascii.c board.c cmdline.c consoleUtils.c delay.c misc.c perf.c systick.c uartStdio.c
  group periph
    periph/: am335x_dmtimer.cpp am335x_dmtimer.h am335x_gpio.cpp am335x_gpio.h am335x_intc.cpp am335x_intc.h am335x_rtc.cpp am335x_rtc.h sys_timer.h
  group periph/pins
    periph/pins/: am3358zcz_pins.cpp am3358zcz_pins.hpp pin.cpp pin.h
  group regs
    regs/: CONTROL_MODULE.CPP CONTROL_MODULE.h DMTIMER.h DMTIMER1MS.h GPIO.h INTC.h PRCM.cpp PRCM.h RTC.hpp
  group utils
    utils/: fsm_timer.cpp fsm_timer.h fsm_timer_capi.h ring_buffer.hpp utils.c utils.h
  group utils/fsm_c
    utils/fsm_c/: fsm.c fsm.h fsm_sheduler.c fsm_types_capi.h ring_buffer.c ring_buffer.h
  group utils/fsm_c/fsm_list
    utils/fsm_c/fsm_list/: test_fsm_a.c test_fsm_b.c test_fsm_c.c
  group utils/fsm_cpp
    utils/fsm_cpp/: fsm.cpp fsm.h fsm_sheduler.cpp fsm_sheduler.h fsm_types_capi.h
  group utils/fsm_cpp/fsm_list
    utils/fsm_cpp/fsm_list/: fsm_list_common.cpp test_fsm_a.cpp test_fsm_b.cpp test_fsm_c.cpp
