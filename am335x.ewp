# IAR project am335x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AM3358 TexasInstruments AM3358
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 53
  General.FPU2: 3
  ICCARM.CCIncludePath2: lib\include; lib; src; lib\include\hw; lib\include\armv7a; lib\include\armv7a\am335x; vendor\freertos\include; vendor\freertos\portable\gcc\ARM_CA8
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: lib; lib\include; vendor\freertos\portable\gcc\ARM_CA8; src
  OBJCOPY.OOCOutputFile: am335x.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: E:\5.Git\proj\repliclay_sw.icf
  ILINK.IlinkAdditionalLibs: lib\drivers.lib; lib\platform.lib; lib\system.lib; lib\utils.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: repliclay_sw.icf
  group freertos
    vendor/freertos/: event_groups.c list.c queue.c tasks.c timers.c
  group freertos/memmang
    vendor/freertos/portable/memmang/: heap_3.c
  group freertos/portable
    vendor/freertos/portable/gcc/ARM_CA8/: port.c portASM.h portASM.S portmacro.h
  group src
    src/: dmtimerCounter.c FreeRTOSConfig.h main.cpp platform.c
